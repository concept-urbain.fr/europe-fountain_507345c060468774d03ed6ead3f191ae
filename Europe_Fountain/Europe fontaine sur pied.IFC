Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Europe fontaine sur pied.IFC
Time: 2020-07-03T11:48:21
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: EURO-FON-PIE-012_Default
In: Default Storey
Material: AISI 304

# IfcBeam: EURO-FON-PIE-016_Default
In: Default Storey
Material: AISI 304

# IfcBeam: EURO-FON-PIE-017_Default (2)
In: Default Storey
Material: AISI 304

# IfcBeam: socket countersunk head screw_iso_Default
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EURO-FON-MUL-001_Default
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: EURO-FON-PIE-004_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 75.4404; Area Measure: 4.13921; Volume Measure: 0.0207673

# IfcBuildingElementProxy: EURO-FON-PIE-011_Default
In: Default Storey
Material: Ductal

# IfcBuildingElementProxy: EURO-FON-PIE-013_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: socket countersunk head screw_iso_Default (3)
In: Default Storey
Material: Steel
