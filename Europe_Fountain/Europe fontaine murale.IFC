Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Europe fontaine murale.IFC
Time: 2020-07-03T11:47:40
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: EURO-FON-MUL-001_Default
In: Default Storey
Material: Steel

# IfcBeam: EURO-FON-MUR-002_Default
In: Default Storey
Material: AISI 304

# IfcBeam: EURO-FON-MUR-017_Default (2)
In: Default Storey
Material: AISI 304

# IfcBeam: EURO-FON-PIE-016_Default
In: Default Storey
Material: AISI 304

# IfcBeam: SPE-FON-MUR-001_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: EURO-FON-MUR-006-01_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 23.6135; Area Measure: 1.44418; Volume Measure: 0.00358182

# IfcBuildingElementProxy: EURO-FON-MUR-016_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: EURO-FON-MUR-017_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: EURO-FON-MUR-018_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: EURO-FON-PIE-013_Default
In: Default Storey
Material: AISI 304
